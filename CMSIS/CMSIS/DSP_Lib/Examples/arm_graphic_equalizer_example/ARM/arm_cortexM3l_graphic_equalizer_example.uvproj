# Keil uVision project arm_cortexM3l_graphic_equalizer_example.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: arm_cortexM3l_graphic_equalizer_example
  c flags: Optim=1 wLevel=2
  c define: ARM_MATH_CM3
  c include: ..\..\..\..\Include;..\..\Common\Include;..\..\..\..\..\Device\ARM\ARMCM3\Include
  group Source Group 1
    ../: arm_graphic_equalizer_data.c arm_graphic_equalizer_example_q31.c
    ../../Common/Source/: math_helper.c
  group CMSIS Device
    ../../Common/ARM/: startup_ARMCM3.s
    ../../Common/: system_ARMCM3.c
  group CMSIS DSP_Library
    ../../../../Lib/ARM/: arm_cortexM3l_math.lib
