# Keil uVision project arm_cortexM0l_convolution_example.uvproj, settings and files
target Target 1 (ARM-GNU)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: arm_cortexM0l_convolution_example
  group Source Group 1
    ../: arm_convolution_example_f32.c
    ../../Common/Source/: math_helper.c
  group CMSIS Device
    ../../Common/GCC/: startup_ARMCM0.S
    ../../Common/: system_ARMCM0.c
